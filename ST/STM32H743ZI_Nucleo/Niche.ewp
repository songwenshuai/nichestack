# IAR project Niche.ewp, settings and files
configuration source (ARM, debug)
  General.OGChipSelectEditMenu: STM32H743ZI ST STM32H743ZI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32H743xx
  ICCARM.CCIncludePath2: ..; ..\APP; ..\BSP\STM32H743ZI_Nucleo; ..\BSP\SDK\STM32CubeH7\Drivers\CMSIS\Device\ST\STM32H7xx\Include; ..\BSP\SDK\STM32CubeH7\Drivers\STM32H7xx_HAL_Driver\Inc; ..\BUTTON; ..\COMMON; ..\ETHERNET; ..\FATFS; ..\..\FatFs\driver; ..\..\FatFs\src; ..\..\FatFs\src\drivers; ..\..\FatFs\src\option; ..\..\Micrium\Software\uC-CPU; ..\..\Micrium\Software\uC-CPU\ARM-Cortex-M4\IAR; ..\..\Micrium\Software\uC-LIB; ..\..\Micrium\Software\uCOS-II; ..\..\Micrium\Software\uCOS-II\Source; ..\..\Micrium\Software\uCOS-II\Ports\ARM-Cortex-M\ARMv7-M\IAR; ..\..\Micrium\Software\uCOS-II\Trace\SystemView\Cfg\Template; ..\..\Micrium\Software\uCOS-II\Trace\SystemView\Source; ..\..\Micrium\Software\uCOS-II\Trace\SystemView\ThirdPartyLibrary\Config; ..\..\Micrium\Software\uCOS-II\Trace\SystemView\ThirdPartyLibrary\SEGGER; ..\..\Niche\allports; ..\..\Niche\autoip4; ..\..\Niche\crypt; ..\..\Niche\ftp; ..\..\Niche\h; ..\..\Niche\h\target; ..\..\Niche\ip; ..\..\Niche\ipmc; ..\..\Niche\misclib; ..\..\Niche\net; ..\..\Niche\target; ..\..\Niche\tcp; ..\..\Niche\telnet; ..\..\Niche\tftp; ..\..\Niche\vfs; ..\..\Niche\web
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Niche.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ..\BSP\Startup\STM32H7xx\IAR\stm32h743xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Doc
    ../../Doc/: Rademe.txt
  group FatFs/Core
    ../../FatFs/src/: diskio.c ff.c ff_gen_drv.c
  group FatFs/Options
    ../../FatFs/src/option/: syscall.c unicode.c
  group Micrium/Software/uC-CPU
    ../../Micrium/Software/uC-CPU/: cpu_cache.h cpu_core.c cpu_core.h cpu_def.h
  group Micrium/Software/uC-CPU/ARM-Cortex-M4/IAR
    ../../Micrium/Software/uC-CPU/ARM-Cortex-M4/IAR/: cpu.h cpu_a.asm cpu_c.c
  group Micrium/Software/uC-LIB
    ../../Micrium/Software/uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_str.c lib_str.h
  group Micrium/Software/uCOS-II/Ports/ARM-Cortex-M/IAR
    ../../Micrium/Software/uCOS-II/Ports/ARM-Cortex-M/ARMv7-M/IAR/: os_cpu.h os_cpu_a.asm os_cpu_c.c os_dbg.c
  group Micrium/Software/uCOS-II/Source
    ../../Micrium/Software/uCOS-II/Source/: os.h os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c os_trace.h ucos_ii.h
  group Micrium/Software/uCOS-II/Trace/SystemView/Cfg/Template
    ../../Micrium/Software/uCOS-II/Trace/SystemView/Cfg/Template/: os_cfg_trace.h
  group Micrium/Software/uCOS-II/Trace/SystemView/Source
    ../../Micrium/Software/uCOS-II/Trace/SystemView/Source/: os_trace_events.h
  group Micrium/Software/uCOS-II/Trace/SystemView/ThirdPartyLibrary/Config
    ../../Micrium/Software/uCOS-II/Trace/SystemView/ThirdPartyLibrary/Config/: SEGGER_RTT_Conf.h SEGGER_SYSVIEW_Conf.h
  group Micrium/Software/uCOS-II/Trace/SystemView/ThirdPartyLibrary/Sample/uCOS-II
    ../../Micrium/Software/uCOS-II/Trace/SystemView/ThirdPartyLibrary/Sample/uCOS-II/: SEGGER_SYSVIEW_uCOSII.c
  group Micrium/Software/uCOS-II/Trace/SystemView/ThirdPartyLibrary/Sample/uCOS-II/Config/Cortex-M
    ../../Micrium/Software/uCOS-II/Trace/SystemView/ThirdPartyLibrary/Sample/uCOS-II/Config/Cortex-M/: SEGGER_SYSVIEW_Config_uCOSII.c
  group Micrium/Software/uCOS-II/Trace/SystemView/ThirdPartyLibrary/SEGGER
    ../../Micrium/Software/uCOS-II/Trace/SystemView/ThirdPartyLibrary/SEGGER/: Global.h SEGGER.h SEGGER_RTT.c SEGGER_RTT.h SEGGER_SYSVIEW.c SEGGER_SYSVIEW.h SEGGER_SYSVIEW_ConfDefaults.h SEGGER_SYSVIEW_Int.h
  group Niche/Allports
    ../../Niche/allports/: allports.c timeouts.c tk_misc.c
  group Niche/AutoIP4
    ../../Niche/autoip4/: autoip.c autoip.h ds_app.h readme.txt upnp.c upnp.h upnpmenu.c
  group Niche/Crypt
    ../../Niche/crypt/: md4.c md4.h md5.c md5.h readme.txt
  group Niche/Ftp
    ../../Niche/ftp/: ftpclnt.c ftpclnt.h ftpcport.c ftpcprn.c ftpmenu.c ftpport.h ftpsport.c ftpsrv.c ftpsrv.h ftpssock.c ftpsvfs.c readme.txt
  group Niche/H
    ../../Niche/h/: app_ping.h arp.h bsdsock.h comline.h crypt_api.h crypt_port.h dhcpclnt.h dns.h dnsport.h ether.h genlist.h htcmptab.h icmp.h ifmap.h in_utils.h iniche_log.h iniche_log_port.h intimers.h ip.h ip6.h libport.h mbuf.h memwrap.h menu.h msring.h nameser.h net.h netbuf.h nptcp.h nptypes.h ns.h ns_debug.h nvfsio.h nvparms.h pmtu.h ppp_port.h profiler.h q.h snmp_vie.h snmpport.h sockcall.h socket.h socket6.h sockvar.h syslog.h tcp.h tcpapp.h tcpport.h tk_crnos.h udp.h userpass.h vfsfiles.h webport.h
  group Niche/H/target
    ../../Niche/h/target/: ipport.h
  group Niche/IP
    ../../Niche/ip/: et_arp.c icmp.c iface.c ip.c ip_reasm.c ip_reasm.h ipdemux.c ipmc.c ipnet.c ipport.c ipraw.c iproute.c ipstart.c pmtu.c readme.txt rtbtree.c udp.c
  group Niche/Ipmc
    ../../Niche/ipmc/: igmp.c igmp.h igmp2.c igmp2.h igmp_cmn.c igmp_cmn.h ipmult.txt ipopt.c readme.txt u_mctest.c
  group Niche/Misclib
    ../../Niche/misclib/: app_ping.c bsdsock.c cksum.c cu_srv.c dhcsetup.c genlist.c in_utils.c iniche_log.c iniche_qsort.c localtime.c memdev.c memio.c memwrap.c menulib.c menus.c msring.c netmain.c nextcarg.c nrmenus.c nvfsio.c nvparms.c parseip.c pcycles.c profiler.c rawiptst.c reshost.c rfsim.c rttest.c soperr.c strilib.c strlib.c strtol.c syslog.c tcp_echo.c tcpcksum.c testmenu.c tk_crnos.c ttyio.c udp_echo.c userpass.c
  group Niche/Net
    ../../Niche/net/: dhcpclnt.c dhcputil.c dnsclnt.c heapbuf.h ifmap.c macloop.c ping.c pktalloc.c q.c readme.txt slip.c slip.h slipif.c slipport.h udp_open.c
  group Niche/Target
    ../../Niche/target/: asm_cksum.S brdutils.c osport.h osportco.c targnios.c
  group Niche/Tcp
    ../../Niche/tcp/: in_pcb.c in_pcb.h nptcp.c protosw.h rawsock.c readme.txt sockcall.c socket.c socket2.c soselect.c tcp_fsm.h tcp_in.c tcp_menu.c tcp_out.c tcp_seq.h tcp_subr.c tcp_timr.c tcp_timr.h tcp_usr.c tcp_var.h tcp_zio.c tcpip.h tcpport.c tcpsack.c udpsock.c
  group Niche/Telnet
    ../../Niche/telnet/: readme.txt telerr.c telmenu.c telnet.c telnet.h telparse.c telport.c telport.h
  group Niche/Tfpt
    ../../Niche/tftp/: readme.txt tftp.h tftpcli.c tftpmenu.c tftpport.c tftpport.h tftpsrv.c tftpudp.c tftputil.c
  group Niche/Vfs
    ../../Niche/vfs/: readme.txt vfsfiles.c vfsport.c vfsport.h vfssync.c vfsutil.c
  group Niche/Web
    ../../Niche/web/: http_data.c http_fs.c http_port.h http_stub.c
  group ST
    ../: app_cfg.h cpu_cfg.h lib_cfg.h
  group ST/APP
    ../APP/: app_hooks.c main.c os_cfg.h
  group ST/BSP/Interrupts
    ../BSP/Interrupts/: bsp_int_armv7m.c README_INTERRUPT.txt
  group ST/BSP/SDK/STM32CubeH7/Drivers/CMSIS
    ../BSP/SDK/STM32CubeH7/Drivers/CMSIS/Device/ST/STM32H7xx/Include/: stm32h743xx.h stm32h7xx.h system_stm32h7xx.h
  group ST/BSP/SDK/STM32CubeH7/Drivers/STM32H7xx_HAL_Driver/Inc
    ../BSP/SDK/STM32CubeH7/Drivers/STM32H7xx_HAL_Driver/Inc/: stm32h7xx_hal.h stm32h7xx_hal_adc.h stm32h7xx_hal_adc_ex.h stm32h7xx_hal_cortex.h stm32h7xx_hal_def.h stm32h7xx_hal_dma.h stm32h7xx_hal_dma_ex.h stm32h7xx_hal_eth.h stm32h7xx_hal_eth_ex.h stm32h7xx_hal_flash.h stm32h7xx_hal_flash_ex.h stm32h7xx_hal_gpio.h stm32h7xx_hal_gpio_ex.h stm32h7xx_hal_pwr.h stm32h7xx_hal_pwr_ex.h stm32h7xx_hal_rcc.h stm32h7xx_hal_rcc_ex.h stm32h7xx_hal_spi.h stm32h7xx_hal_spi_ex.h stm32h7xx_hal_tim.h stm32h7xx_hal_tim_ex.h stm32h7xx_hal_uart.h stm32h7xx_hal_uart_ex.h
  group ST/BSP/SDK/STM32CubeH7/Drivers/STM32H7xx_HAL_Driver/Inc/Legacy
    ../BSP/SDK/STM32CubeH7/Drivers/STM32H7xx_HAL_Driver/Inc/Legacy/: stm32_hal_legacy.h
  group ST/BSP/SDK/STM32CubeH7/Drivers/STM32H7xx_HAL_Driver/Src
    ../BSP/SDK/STM32CubeH7/Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group ST/BSP/Startup
    ../BSP/Startup/STM32H7xx/: system_stm32h7xx.c
  group ST/BSP/Startup/IAR
    ../BSP/Startup/STM32H7xx/IAR/: startup_stm32h743xx.s stm32h743xx_flash.icf
  group ST/BSP/STM32H743ZI_Nucleo
    ../BSP/STM32H743ZI_Nucleo/: bsp_clk.c bsp_clk.h bsp_cpu.c bsp_int.h bsp_led.c bsp_led.h bsp_os.c bsp_os.h bsp_pb.c bsp_pb.h bsp_sd.c bsp_sd.h bsp_spi.c bsp_spi.h bsp_usart.c bsp_usart.h stm32h7xx_hal_conf.h
  group ST/BUTTON
    ../BUTTON/: btntask.c button.c button.h
  group ST/COMMON
    ../COMMON/: compiler_port.h cpu_endian.c cpu_endian.h date_time.c date_time.h debug.c debug.h error.h os_port.h os_port_config.h os_port_ucos2.c os_port_ucos2.h str.c str.h
  group ST/ETHERNET
    ../ETHERNET/: ifec.c ifec.h stm32h7xx_eth_driver.c stm32h7xx_eth_driver.h
  group ST/FATFS
    ../FATFS/: ffconf.h fftest.c fftest.h sd_diskio.c sd_diskio.h
